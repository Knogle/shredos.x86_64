# Ensure C++ support is enabled
EXTRA_OECONF:remove = "--disable-cxx"
