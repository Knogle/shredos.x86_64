FILESEXTRAPATHS:prepend = "${THISDIR}/files:"
SRC_URI += "file://overlayfs.cfg"
